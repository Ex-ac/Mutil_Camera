# Keil uVision project camera.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: camera +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --cpp11
  c include: .\Driver;.\fatfs;.\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: AbstractSignal.cpp AbstractSignal.h generalizeddatastructure.h globalvariable.cpp globalvariable.h main.cpp Protocols.cpp Protocols.h public.cpp public.h stm32f10x_it.c stm32f10x_it.h
  group Driver
    ./Driver/: Exti.h PixelBase.cpp PixelBase.h sdio_sd.c sdio_sd.h SpiMaster.cpp SpiMaster.h sysTick.cpp sysTick.h Exti.cpp usart.h usart.cpp
  group FatFs
    ./fatfs/: diskio.c ff.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
